options:
  parameters:
    author: Indrani
    generate_options: qt_gui
    id: step02_single_tone
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: pri
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: '10e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: ''
    packet_len: '200'
    pulse_amplitude: '1.0'
    pulse_len: '[20]'
    pulse_pause: '[180]'
  states: {}

connections:
- [radar_signal_generator_sync_pulse_c_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
