options:
  parameters:
    author: Indrani
    generate_options: qt_gui
    id: step02_single_tone
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baseband_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: emitter1_amplitude
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: emitter2_amplitude
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: emitter2_baseband_freq
  id: variable
  parameters:
    value: '-250e3'
  states: {}
- name: emitter2_id
  id: variable
  parameters:
    value: '2'
  states: {}
- name: emitter2_packet_samples
  id: variable
  parameters:
    value: emitter2_pri_samples
  states: {}
- name: emitter2_pri
  id: variable
  parameters:
    value: '70e-6'
  states: {}
- name: emitter2_pri_samples
  id: variable
  parameters:
    value: int(round(emitter2_pri * samp_rate))
  states: {}
- name: emitter2_pulse_samples
  id: variable
  parameters:
    value: int(round(emitter2_pulse_width * samp_rate))
  states: {}
- name: emitter2_pulse_width
  id: variable
  parameters:
    value: '4e-6'
  states: {}
- name: emitter2_rf_freq
  id: variable
  parameters:
    value: 8e9
  states: {}
- name: emitter2_wait_samples
  id: variable
  parameters:
    value: emitter2_pri_samples - emitter2_pulse_samples
  states: {}
- name: emitter_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: emitter_rf_freq
  id: variable
  parameters:
    value: 3.2e9
  states: {}
- name: jitter_fraction
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: jitter_max
  id: variable
  parameters:
    value: pri * jitter_fraction
  states: {}
- name: noise_amplitude
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: '0.0025'
  states: {}
- name: packet_samples
  id: variable
  parameters:
    value: pri_samples
  states: {}
- name: pri
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: pri_max
  id: variable
  parameters:
    value: pri + jitter_max
  states: {}
- name: pri_min
  id: variable
  parameters:
    value: pri - jitter_max
  states: {}
- name: pri_samples
  id: variable
  parameters:
    value: int(round(pri * samp_rate))
  states: {}
- name: pulse_samples
  id: variable
  parameters:
    value: int(round(pulse_width * samp_rate))
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: '10e-6'
  states: {}
- name: random_seed
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: wait_samples
  id: variable
  parameters:
    value: pri_samples - pulse_samples
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: baseband_freq
    offset: '0.0'
    phase: '0.0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1.0'
    freq: emitter2_baseband_freq
    offset: '0.0'
    phase: '0.0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: emitter_rf_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: ''
    packet_len: packet_samples
    pulse_amplitude: emitter1_amplitude
    pulse_len: pulse_samples
    pulse_pause: wait_samples
  states: {}
- name: radar_signal_generator_sync_pulse_c_0_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: ''
    packet_len: emitter2_packet_samples
    pulse_amplitude: emitter2_amplitude
    pulse_len: emitter2_pulse_samples
    pulse_pause: emitter2_wait_samples
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_multiply_xx_0, '0']
- [radar_signal_generator_sync_pulse_c_0_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
